<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\netconn_server_rtos.ewp</path>
  </project>
  <batchBuild />
</workspace>
