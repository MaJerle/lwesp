# Keil uVision project esp_dev_rtos.uvprojx, settings and files
target NUCLEO_F411 HSE 8MHz (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F411xE,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,ARM_MATH_CM4,STM32F4XX,NUCLEO_F411,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLM=8,RCC_PLLN=400,RCC_PLLP=4,RCC_PLLQ=7,
  c include: .\User;..\src\include;..\libs;..\libs\st_hal\STM32F4xx_HAL_Driver\Inc;..\libs\st_hal\CMSIS\Device\ST\STM32F4xx\Include;..\libs\st_hal\CMSIS\Include;..\libs\FreeRTOS\include;..\libs\FreeRTOS\CMSIS_RTOS;..\libs\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --callgraph
  group STM32F4_HAL_Drivers
    ../libs/st_hal/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_dma.c stm32f4xx_ll_usart.c stm32f4xx_ll_rcc.c stm32f4xx_ll_gpio.c
  group STM32F7_HAL_Drivers
    ../libs/st_hal/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_dma.c stm32f7xx_ll_usart.c stm32f7xx_ll_rcc.c stm32f7xx_ll_gpio.c
  group TM
    ../libs/: tm_stm32_buffer.c tm_stm32_delay.c tm_stm32_disco.c tm_stm32_general.c tm_stm32_gpio.c tm_stm32_rcc.c tm_stm32_usart.c
  group User
    ./User/: main.c stm32fxxx_it.c fs_data.c
  group FreeRTOS
    ../libs/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../libs/FreeRTOS/portable/RVDS/ARM_CM4F/: port_cm4.c
    ../libs/FreeRTOS/portable/MemMang/: heap_4.c
    ../libs/FreeRTOS/CMSIS_RTOS/: cmsis_os.c cpu_utils.c
    ../libs/FreeRTOS/portable/RVDS/ARM_CM7/: port_cm7.c
  group ESP
    ../src/esp/: esp.c esp_parser.c esp_threads.c esp_int.c esp_input.c esp_debug.c esp_timeout.c esp_sta.c esp_ap.c esp_conn.c esp_sntp.c esp_ping.c
  group ESP UTILS
    ../src/esp/: esp_unicode.c esp_pbuf.c esp_buff.c esp_mem.c
  group ESP API
    ../src/esp/: esp_netconn.c
  group ESP LL
    ../src/system/: esp_sys.c esp_ll.c
  group ESP HTTP SERVER
    ../src/apps/server/: esp_http_server.c
  group ESP MQTT CLIENT
    ../src/apps/mqtt/: esp_mqtt_client.c
target NUCLEO_F401 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER,USE_FULL_LL_DRIVER,ARM_MATH_CM4,STM32F4XX,NUCLEO_F401,HSE_VALUE=8000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSI,RCC_PLLM=16,RCC_PLLN=336,RCC_PLLP=4,RCC_PLLQ=7,
  c include: .\User;..\src;..\src\esp\include;..\src\system\include;..\libs;..\libs\st_hal\STM32F4xx_HAL_Driver\Inc;..\libs\st_hal\CMSIS\Device\ST\STM32F4xx\Include;..\libs\st_hal\CMSIS\Include;..\libs\FreeRTOS\include;..\libs\FreeRTOS\CMSIS_RTOS;..\libs\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --callgraph
target STM32F769_DISCOVERY (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F769xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,ARM_MATH_CM7,__FPU_PRESENT=1,STM32F7XX,STM32F769_DISCOVERY,HSE_VALUE=25000000,RCC_OSCILLATORTYPE=RCC_OSCILLATORTYPE_HSE,RCC_PLLSOURCE=RCC_PLLSOURCE_HSE,RCC_PLLM=25,RCC_PLLN=432,RCC_PLLP=2,RCC_PLLQ=9
  c include: .\User;..\src;..\src\esp\include;..\src\system\include;..\libs;..\libs\st_hal\STM32F7xx_HAL_Driver\Inc;..\libs\st_hal\CMSIS\Device\ST\STM32F7xx\Include;..\libs\st_hal\CMSIS\Include;..\libs\FreeRTOS\include;..\libs\FreeRTOS\CMSIS_RTOS;..\libs\FreeRTOS\portable\RVDS\ARM_CM7
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.2, Device:Startup 2.6.0, Device:Startup 1.2.0
